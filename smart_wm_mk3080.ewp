# IAR project smart_wm_mk3080.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; USE_RTOS; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; FSL_RTOS_FREE_RTOS; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: source\app_preinclude.h
  ICCARM.CCIncludePath2: board; source; CMSIS; amazon-freertos/freertos/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; component/kv; component/kv/include; device; doc; drivers; src; startup; utilities; xip; csdk\eng; csdk\eng\atm; csdk\eng\dev_model; csdk\eng\dev_sign; csdk\eng\infra; csdk\eng\mqtt; csdk\eng\wrappers; csdk\eng\wrappers\external_libs; csdk\eng\coap_cloud; csdk\eng\coap_server; csdk\eng\coap_server\CoAPPacket; csdk\eng\coap_server\server; csdk\eng\dev_bind; csdk\eng\dev_bind\impl; csdk\eng\dev_bind\impl\os; csdk\eng\dev_bind\impl\awss_reset; mbedtls\include\mbedtls; mbedtls\include; mbedtls\port\ksdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: board; source; CMSIS; amazon-freertos/freertos/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; device; doc; drivers; src; startup; utilities; xip
  OBJCOPY.OOCOutputFile: smart_wm_mk3080.srec
  ILINK.IlinkOutputFile: smart_wm_mk3080.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; NDEBUG; SKIP_SYSCLK_INIT; USE_RTOS; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B; FSL_RTOS_FREE_RTOS; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE; EW_MAX_SURFACE_CACHE_SIZE=0x200000; EW_MAX_GLYPH_SURFACE_WIDTH=256; EW_MAX_GLYPH_SURFACE_HEIGHT=256; EW_USE_DOUBLE_BUFFER=1; EW_USE_FREE_RTOS=1; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; USB_STACK_FREERTOS; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"
  ICCARM.PreInclude: source\app_preinclude.h
  ICCARM.CCIncludePath2: board; source; emgui; emgui/GeneratedCode; emgui/RGB565; emgui/RTE; emgui/TargetSpecific; emgui/TLSF; touchpanel; usb/include; usb/osa; usb/phy; usb/device; source/common_drivers; source/demo_wm; CMSIS; amazon-freertos/freertos/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; component/kv; component/kv/include; device; doc; drivers; src; startup; utilities; xip; csdk\eng; csdk\eng\atm; csdk\eng\dev_model; csdk\eng\dev_sign; csdk\eng\infra; csdk\eng\mqtt; csdk\eng\wrappers; csdk\eng\wrappers\external_libs; csdk\eng\coap_cloud; csdk\eng\coap_server; csdk\eng\coap_server\CoAPPacket; csdk\eng\coap_server\server; csdk\eng\dev_bind; csdk\eng\dev_bind\impl; csdk\eng\dev_bind\impl\os; csdk\eng\dev_bind\impl\awss_reset; mbedtls\include\mbedtls; mbedtls\include; mbedtls\port\ksdk
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: csdk.bin
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1052DVL6B; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  group amazon-freertos
    amazon-freertos/: ChangeLogKSDK.txt directories.txt
  group amazon-freertos/freertos
    amazon-freertos/freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos/portable
    amazon-freertos/freertos/portable/: heap_4.c port.c portasm.s portmacro.h readme.txt
  group amazon-freertos/include
    amazon-freertos/include/: deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h threading_alt.h timers.h
  group amazon-freertos/license
    amazon-freertos/license/: directories.txt
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group component/kv
    component/kv/: kv.c kv_adapt.c kv_cli.c kv_secure.c kv_types.h
  group component/kv/include
    component/kv/include/: kv_adapt.h kv_api.h kv_conf.h kv_err.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: lpuart_adapter.c uart.h
  group csdk/eng
    csdk/eng/: sdk_include.h
  group csdk/eng/atm
    csdk/eng/atm/: at_api.c at_api.h at_conn_mbox.c at_conn_mbox.h at_conn_mgmt.c at_conn_mgmt.h at_parser.c at_parser.h at_tcp.c at_wrapper.h
  group csdk/eng/certs
    csdk/eng/certs/: root_ca.c
  group csdk/eng/coap_server
    csdk/eng/coap_server/: coap_api.h coap_wrapper.h iotx_coap.h iotx_coap_config.h iotx_coap_internal.h
  group csdk/eng/coap_server/CoAPPacket
    csdk/eng/coap_server/CoAPPacket/: CoAPDeserialize.h CoAPDeserialize_common.c CoAPMessage_common.c CoAPPlatform.h CoAPSerialize.h CoAPSerialize_common.c
  group csdk/eng/coap_server/server
    csdk/eng/coap_server/server/: CoAPExport.c CoAPExport.h CoAPInternal.h CoAPMessage.c CoAPMessage.h CoAPNetwork.c CoAPNetwork.h CoAPObserve.c CoAPObserve.h CoAPPlatform.c CoAPResource.c CoAPResource.h CoAPServer.c CoAPServer.h
  group csdk/eng/dev_bind
    csdk/eng/dev_bind/: dev_bind_api.h dev_bind_wrapper.h
  group csdk/eng/dev_bind/impl
    csdk/eng/dev_bind/impl/: awss_bind.c awss_bind_statis.c awss_bind_statis.h awss_cmp.h awss_cmp_coap.c awss_cmp_mqtt.c awss_event.c awss_event.h awss_info.c awss_info.h awss_log.h awss_notify.c awss_notify.h awss_packet.c awss_packet.h awss_report.c awss_reset.h awss_timer.c awss_timer.h awss_utils.h dev_bind_internal.h iot_import_awss.h passwd.c passwd.h
  group csdk/eng/dev_bind/impl/awss_reset
    csdk/eng/dev_bind/impl/awss_reset/: awss_dev_reset.c awss_dev_reset.h awss_dev_reset_internal.h
  group csdk/eng/dev_bind/impl/os
    csdk/eng/dev_bind/impl/os/: os.h os_misc.c
  group csdk/eng/dev_model
    csdk/eng/dev_model/: dev_model_api.h dm_api.c dm_client.c dm_client.h dm_client_adapter.c dm_client_adapter.h dm_cota.c dm_cota.h dm_fota.c dm_fota.h dm_intf.h dm_ipc.c dm_ipc.h dm_log_report.c dm_manager.c dm_manager.h dm_message.c dm_message.h dm_message_cache.c dm_message_cache.h dm_msg_process.c dm_msg_process.h dm_opt.c dm_opt.h dm_ota.c dm_ota.h dm_server.c dm_server.h dm_server_adapter.c dm_server_adapter.h dm_shadow.c dm_shadow.h dm_tsl_alink.c dm_tsl_alink.h dm_utils.c dm_utils.h dm_wrapper.h impl_gateway.c impl_gateway.h impl_linkkit.c impl_ntp.c impl_ntp.h impl_solo.c impl_solo.h iot_export_linkkit.h iotx_cm.c iotx_cm.h iotx_cm_coap.c iotx_cm_coap.h iotx_cm_internal.h iotx_cm_mqtt.c iotx_cm_mqtt.h iotx_dm.h iotx_dm_config.h iotx_dm_internal.h iotx_log_report.h linkkit_export.h linkkit_gateway_export.h
  group csdk/eng/dev_sign
    csdk/eng/dev_sign/: dev_sign_api.h dev_sign_config.h dev_sign_internal.h dev_sign_mqtt.c dev_sign_wrapper.h
  group csdk/eng/infra
    csdk/eng/infra/: infra_cjson.c infra_cjson.h infra_compat.c infra_compat.h infra_config.h infra_defs.c infra_defs.h infra_json_parser.c infra_json_parser.h infra_list.h infra_log.c infra_log.h infra_md5.c infra_md5.h infra_net.c infra_net.h infra_prt_nwk_payload.c infra_report.c infra_report.h infra_sha1.c infra_sha1.h infra_sha256.c infra_sha256.h infra_string.c infra_string.h infra_timer.c infra_timer.h infra_types.h
  group csdk/eng/mqtt
    csdk/eng/mqtt/: iotx_mqtt_client.c iotx_mqtt_client.h iotx_mqtt_config.h mqtt_api.c mqtt_api.h mqtt_internal.h mqtt_wrapper.h MQTTConnect.h MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c
  group csdk/eng/wrappers
    csdk/eng/wrappers/: wrapper.c wrappers_defs.h
  group csdk/eng/wrappers/at_tcp
    csdk/eng/wrappers/at_tcp/: mk3060.c
  group csdk/eng/wrappers/external_libs
    csdk/eng/wrappers/external_libs/: cJSON.c cJSON.h
  group csdk/eng/wrappers/tls
    csdk/eng/wrappers/tls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
  group csdk/examples
    csdk/examples/: dev_sign_example.c linkkit_example_solo.c mqtt_example_at.c
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dcp.c fsl_dcp.h fsl_elcdif.c fsl_elcdif.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h
  group emgui
    emgui/: DeviceDriver.c DeviceDriver.h ewmain.c ewmain.h
  group emgui/GeneratedCode
    emgui/GeneratedCode/: _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CorePropertyObserver.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreSlideTouchHandler.h _CoreSystemEvent.h _CoreSystemEventHandler.h _CoreSystemEventTask.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreVerticalList.h _CoreView.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsInt32Effect.h _EffectsRectEffect.h _EffectsTimingList.h _GraphicsCanvas.h _ResourcesBitmap.h _ResourcesFont.h _ViewsBorder.h _ViewsFrame.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h _WasherDeviceClass.h _WasherHourItemL.h _WasherHourItemS.h _WasherMinItemL.h _WasherMinItemS.h _WasherOptItemL.h _WasherOptItemS.h _WasherOptList.h _WasherProgItemL.h _WasherProgItemS.h _WasherProgList.h _WasherSpinItemL.h _WasherSpinItemS.h _WasherSpinList.h _WasherStartButton.h _WasherTempItemL.h _WasherTempItemS.h _WasherTempList.h _WasherTimeList.h _WasherWasher.h Application.c Application.h Core.c Core.h Effects.c Effects.h ewlocale.h Graphics.c Graphics.h Resources.c Resources.h Templates.c Templates.h Views.c Views.h Washer.c Washer.h
  group emgui/RGB565
    emgui/RGB565/: ewextgfx.c libewgfx-m7-iar.a
  group emgui/RTE
    emgui/RTE/: ewextrte.c libewrte-m7-iar.a
  group emgui/TargetSpecific
    emgui/TargetSpecific/: ew_bsp_clock.c ew_bsp_clock.h ew_bsp_display.c ew_bsp_display.h ew_bsp_event.c ew_bsp_event.h ew_bsp_graphics.c ew_bsp_graphics.h ew_bsp_inout.c ew_bsp_inout.h ew_bsp_serial.c ew_bsp_serial.h ew_bsp_system.c ew_bsp_system.h ew_bsp_touch.c ew_bsp_touch.h
  group emgui/TLSF
    emgui/TLSF/: tlsf.c tlsf.h tlsfbits.h
  group mbedtls/include/mbedtls
    mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group source
    source/: app_preinclude.h csdk.c FreeRTOSConfig.h
  group source/common_drivers
    source/common_drivers/: flexspi_hyper_flash_ops.c flexspi_hyper_flash_ops.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h ip_cmd.c ip_cmd.h shell.c shell.h virtual_com.c virtual_com.h
  group source/demo_wm
    source/demo_wm/: washing_machine.c washing_machine.h
  group src
    src/: evkbimxrt1050.mac MIMXRT1052xxxxx_ram.icf
  group startup
    startup/: startup_MIMXRT1052.s
  group touchpanel
    touchpanel/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group usb/device/class
    usb/device/: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    usb/device/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/include
    usb/device/: usb_device.h
  group usb/device/source
    usb/device/: usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_descriptor.c usb_device_descriptor.h
  group usb/device/source/ehci
    usb/device/: usb_device_ehci.c usb_device_ehci.h
  group usb/include
    usb/include/: usb.h usb_ehci.h usb_misc.h usb_spec.h
  group usb/osa
    usb/osa/: usb_osa.h usb_osa_freertos.c usb_osa_freertos.h
  group usb/phy
    usb/phy/: usb_phy.c usb_phy.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
